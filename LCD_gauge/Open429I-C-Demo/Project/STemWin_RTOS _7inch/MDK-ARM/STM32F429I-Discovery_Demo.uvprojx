# Keil uVision project STM32F429I-Discovery_Demo.uvprojx, settings and files
target STM32F429I-Discovery_Demo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I-Discovery_Demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,USE_EMBEDDED_PHY,
  c misc: --c99 --diag-suppress 111
  c include: .\..\Config;.\..\Core\Devices\STM32F4xx;.\..\Core\User;.\..\Core\Demo;.\..\Core\Lib;.\..\Core\Test_Program;.\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\Utilities;.\..\..\..\Utilities\Common;.\..\..\..\Utilities\STM32F429i-Discovery;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F;.\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include;.\..\..\..\Libraries\STemWinLibrary522_4x9i\inc;.\..\..\..\Libraries\STemWinLibrary522_4x9i\Config;..\Core\User\TouchPanel;..\..\..\Utilities\STM32F429I_Lib
  asm include: .\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Appli
    ./../Core/User/: bsp.c main.c rtc.c stm32xxx_it.c
    ./../Core/Devices/STM32F4xx/: system_stm32f4xx.c
    ./: startup_stm32f429_439xx.s
  group Libraries
    ./../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIConf.c
    ./../../../Libraries/STemWinLibrary522_4x9i/OS/: GUI_X_FreeRTOS.c
    ./../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../../../Libraries/STemWinLibrary522_4x9i/Lib/: STemWin522_4x9i_CM4_OS_Keil.lib
    ../../../Utilities/STM32F429I_Lib/: stm32f429i_sdram_lib.c stm32f429i_ioe_lib.c stm32f429i_lcd_lib.c stm32f429i_lib.c
    ../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIDRV.c
  group Utilities
    ./../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ./../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port_cm4.c
  group AutomotivePanel
    ../Core/AutomotivePanel/: automotivePanel.c picto.c
software components: CMSIS:CORE 4.1.0
